# Keil uVision project c8051f321.uvproj, settings and files
target silabs_c2adapter (MCS-51)
  device: C8051F321 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: silabs_c2adapter +hex
  BeforeMake: pre_build.bat $P.. @L
  AfterMake: post_build.bat $P.. @L
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\apl;..\drv;..\plf;..\cfg;..\pkt;..\lib;..\os;..\porting;..\cli;..\cli\cmd;..\dev
  asm include: as above
  link misc: REMOVEUNUSED
  group packet
    ../pkt/: thread_pkt.c pkt_system.c pkt_i2cm.c pkt_mdiom.c pkt_c2m.c
  group platform
    ../plf/: thread_idle.c thread_led.c main.c
  group configuration
    ../cfg/: cfg.c cfg_db.c cfg_pwd.c
  group driver
    ../drv/: startup.S drv.c drv_cpu.c drv_vector.c drv_io.c drv_usb.c drv_adc.c drv_flash.c drv_pca.c drv_i2cm.c drv_c2m.c drv_mdiom.c usbxpress_lib_f32x.lib
  group os
    ../os/: os.c
  group library
    ../lib/: _stdio.c _string.c
  group application
    ../apl/: apl.c
